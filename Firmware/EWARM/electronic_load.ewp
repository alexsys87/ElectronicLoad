# IAR project electronic_load.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xC; APP_LOAD
  ICCARM.CCIncludePath2: ..\src; ..\load; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: electronic_load.hex
  ILINK.IlinkOutputFile: electronic_load.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Load
    ../load/: main.c load.c measure.c ads1115.c i2c.c analog.c output.c fan.c load_config.h
  group Common
    ../src/: px100.c board.c system.c usb_cdc.c config.h
  group Startup
    ./: startup_stm32f401xc.s
