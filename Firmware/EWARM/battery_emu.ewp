# IAR project battery_emu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xC
  ICCARM.CCIncludePath2: ..\src; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: battery_emu.hex
  ILINK.IlinkOutputFile: battery_emu.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Application
    ../src/: main.c battery_emu.c px100.c config.h
  group Drivers
    ../src/: board.c system.c usb_cdc.c
  group Startup
    ./: startup_stm32f401xc.s
